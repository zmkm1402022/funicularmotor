# Keil uVision project ChamberCtrlUnit_v1.0.uvprojx, settings and files
target ChamberCtrlUnit (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ChamberCtrlUnit +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER, EN_USART1,UART1_PRINTF
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\RS485;..\HARDWARE\CAN;..\SYSTEM\sys;..\HARDWARE\ADC;..\USER;..\HARDWARE\WatchDOG;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\RTC;..\HARDWARE\WDG;..\HARDWARE\DS18B20;..\HARDWARE\DS1302;..\HARDWARE\MotorControl;..\HARDWARE\pid;..\HARDWARE\cryptoauthlib\lib\hal;..\HARDWARE\cryptoauthlib\lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/CAN/: can.c canard.c
    ../HARDWARE/ADC/: OCPSampling.c
    ../HARDWARE/DS18B20/: DS18.c
    ../HARDWARE/MotorControl/: exDCMotor.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: timerapp.c
  group CORE
    ../CORE/: core_cm3.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_i2c.c
  group README
    ../: README.TXT
  group HeaderFile
    ./: stm32f10x_conf.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
